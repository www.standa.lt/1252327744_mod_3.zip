# Autodesk Inventor part: 7T273-10Tuzsakovui
## iProperties
Created: 2006-11
Part Number: 7T273-10Tuzsakovui
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
